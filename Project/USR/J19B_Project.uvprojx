# Keil uVision project J19B_Project.uvprojx, settings and files
target STM32F103ZET6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: J19B_Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\ARM-Cortex-M3\CORE;..\..\ARM-Cortex-M3\FWLib\inc;..\..\ARM-Cortex-M3\SYSTEM\delay;..\..\ARM-Cortex-M3\SYSTEM\sys;..\..\SystemView\SEGGER;..\BSP;..\APP;..\PTC;..\BSP\iic;..\BSP\led;..\BSP\timer;..\BSP\usart;..\PTC\ads1115;..\PTC\gy68;..\PTC\sht31;..\ALG\kalman;..\ALG\avrfilter;..\PTC\nb-iot;..\ALG\hexstring;..\BSP\iwdog;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\SystemView\Config;..\..\SystemView\Sample\FreeRTOSV10\Config;..\..\SystemView\Sample\FreeRTOSV10\Patch;..\..\SystemView\Sample\FreeRTOSV10
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../../ARM-Cortex-M3/CORE/: startup_stm32f10x_hd.s
  group FreeRTOS_CORE
    ../../FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group CORE
    ../../ARM-Cortex-M3/CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../../ARM-Cortex-M3/SYSTEM/delay/: delay.c
    ../../ARM-Cortex-M3/SYSTEM/sys/: sys.c
  group FWLib
    ../../ARM-Cortex-M3/FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group SV
    ../../SystemView/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    ../../SystemView/Sample/FreeRTOSV10/: SEGGER_SYSVIEW_FreeRTOS.c
    ../../SystemView/Sample/FreeRTOSV10/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ./: SystemView.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/led/: led.c
    ../BSP/timer/: timer.c
    ../BSP/usart/: usart3_pm.c usart2_send.c
    ../BSP/iic/: iic_ADS.c iic_HTS.c
    ../BSP/iwdog/: iwdog.c
  group PTC
    ../PTC/: ptc.c
    ../PTC/nb-iot/: nbiot.c
    ../PTC/ads1115/: ads1115.c
    ../PTC/sht31/: sht31.c
    ../PTC/gy68/: bmp180.c
  group APP
    ../APP/: app.c
  group ALG
    ../ALG/kalman/: kalman.c
    ../ALG/avrfilter/: avrfilter.c
    ../ALG/hexstring/: hexstring.c
  group USR
    ../APP/: main.c
software components: CMSIS:CORE 5.0.1
